TYPE st_PosXYZ :
STRUCT
	lPosX:LREAL;
	lPosY:LREAL;
	lPosZ:LREAL;
END_STRUCT
END_TYPE
