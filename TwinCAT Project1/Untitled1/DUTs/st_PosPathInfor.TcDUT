TYPE st_PosPathInfor :
STRUCT
	st_PosXYZ:st_PosXYZ;
	IsHadWork:BOOL;
END_STRUCT
END_TYPE
