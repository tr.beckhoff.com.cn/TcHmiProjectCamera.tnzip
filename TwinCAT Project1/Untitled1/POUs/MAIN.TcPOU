PROGRAM MAIN
VAR
	lTest:ARRAY [0..100] OF LREAL;
	sHttp:STRING(10000):='https://www.beckhoff.com.cn/';
	sCameraName: ARRAY[0..2]OF STRING:=['null','null','null'];

END_VAR

END_PROGRAM
